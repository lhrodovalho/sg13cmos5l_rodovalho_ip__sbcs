v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 290 -240 0 0 {name=p1 lab=D}
C {devices/iopin.sym} 290 -200 0 0 {name=p2 lab=G}
C {devices/iopin.sym} 290 -160 0 0 {name=p3 lab=S}
C {devices/iopin.sym} 290 -120 0 0 {name=p4 lab=B}
C {devices/code_shown.sym} 20 -90 0 0 {name=s1 only_toplevel=false value="
X0 d g s b sg13_hv_pmos W=4.5u L=2.5u ng=1 m=1
"}
